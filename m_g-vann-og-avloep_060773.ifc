Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [Default Description]
File name: \\files\Projects\RWA2024N005XX\RWA2024N00575\VA\Modell\G-eks VA.ifc
Time: 2026-02-27T08:04:45
Author: Jørgen Dybdahl
Organization: Trimble Solutions Sandvika AS
Written by: Ifc Engine <1.0.1.1369>
Made in: Trimble Inc. - Novapoint - 27.0.999.0
Authorization: Jørgen Dybdahl

# IfcProject, Default Project
Description: Description of the Project

# IfcSite, Default Site
Description: Description of Site; RefLatitude: 5, 7, 11; RefLongitude: 60, 51, 0; RefElevation: 10.5112 m

# IfcBuilding, Default Building
Description: Description of Building; ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0

# IfcBuildingStorey
In: Default Building
Description: Land Development storey; Elevation: 0 m

# IfcDistributionFlowElement (12)
Novapoint UtilityNetwork - ManholeMateriale: Betong; ManholeHasLadder: 0
Common - Color: 0.0.0
Merknader - G004 Diameter: 1000
Name | Name | Navn = G100 Ledningstype | ManholeHeight | ManholeElevationAtTop | ManholeTaperDiameter | ManholeAdjustingUnitHeight | ManholeInnerBottomZ | ManholeSumpDepth | Bruksomraade
02.03.03.01 Eksisterende VA, O37 | 02.03.03.01 Eksisterende VA. O37 | O37 | 1.24155 | 14.0597 | 0 | 0 | 12.8181 | 0 | Inspeksjonskum
02.03.03.01 Eksisterende VA, SA43 | 02.03.03.01 Eksisterende VA. SA43 | SA43 | 2.00035 | 15.686 | 650 | 100 | 13.6856 | 1000 | Merknader - G009 Lokktype: SJK Kuppelrist
02.03.03.01 Eksisterende VA, O35 | 02.03.03.01 Eksisterende VA. O35 | O35 | 2.70688 | 16.9855 | 0 | 0 | 14.2786 | 0 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O30 | 02.03.03.01 Eksisterende VA. O30 | O30 | 1.61044 | 13 | 0 | 0 | 11.3896 | 0 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O28 | 02.03.03.01 Eksisterende VA. O28 | O28 | 1.47382 | 16.1453 | 0 | 0 | 14.6715 | 0 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O32 | 02.03.03.01 Eksisterende VA. O32 | O32 | 0.638691 | 11.25 | 0 | 0 | 10.6113 | 0 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O36 | 02.03.03.01 Eksisterende VA. O36 | O36 | 2.62101 | 16.0199 | 0 | 0 | 13.3989 | 0 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O34 | 02.03.03.01 Eksisterende VA. O34 | O34 | 0.853 | 15.1543 | 0 | 0 | 14.3013 | 0 | Inspeksjonskum
02.03.03.01 Eksisterende VA, Lokk og kjegle tas inn i rivemodell | 02.03.03.01 Eksisterende VA. Lokk og kjegle tas inn i rivemodell | Lokk og kjegle tas inn i rivemodell | 2.22399 | 16.873 | 650 | 100 | 14.649 | 304 | Merknader - G009 Lokktype: SJK Rist
02.03.03.01 Eksisterende VA, O8 | 02.03.03.01 Eksisterende VA. O8 | O8 | 0.798 | 43.524 |  | 0 | 42.726 | 0 | Inspeksjonskum | Merknader - G009 Lokktype: SJK Rist; Novapoint UtilityNetwork - ManholeLength: 720; ManholeWidth: 700
02.03.03.01 Eksisterende VA, O33 | 02.03.03.01 Eksisterende VA. O33 | O33 | 1.33978 | 15.6038 | 0 | 0 | 14.264 | 0 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O29 | 02.03.03.01 Eksisterende VA. O29 | O29 | 1.93685 | 13.9635 | 0 | 0 | 12.0266 | 0 | Inspeksjonskum

# IfcFlowSegment (22)
Novapoint UtilityNetwork - Navn: Overvannsledning; PipeNetworkUsage: Surface Water; Volume: 0 m3
Common - Color: 0.0.0
Merknader - G100 Ledningstype: Overvannsledning
Name | Name | Length (m) | G107 Lengde | G101 Fra kum | G102 Til kum | G103 Innvendig dimensjon | G104 Utvendig dimensjon
02.03.03.01 Eksisterende VA, Trase_VA1, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase_VA1. Overvannsledning | 135.132 | 135.13 | O37 | O29 | 500 | 670 | Novapoint UtilityNetwork - ToConnection: 02.03.03.01 Eksisterende VA. O29; FromConnection: 02.03.03.01 Eksisterende VA. O37
02.03.03.01 Eksisterende VA, Trase12, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase12. Overvannsledning | 20.0724 | 20.0724 | O28 | SA43 | 250 | 346 | Novapoint UtilityNetwork - ToConnection: 02.03.03.01 Eksisterende VA. SA43; FromConnection: 02.03.03.01 Eksisterende VA. O28
02.03.03.01 Eksisterende VA, Trase11, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase11. Overvannsledning | 3.12364 | 3.12348 | Bend | Bend | 300 | 406
02.03.03.01 Eksisterende VA, Trase7, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase7. Overvannsledning | 12.308 | 12.2085 | Bend | Bend | 300 | 406
02.03.03.01 Eksisterende VA, Trase1, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase1. Overvannsledning | 10.8983 | 10.8373 | Bend | Bend | 300 | 406
02.03.03.01 Eksisterende VA, Trase9, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase9. Overvannsledning | 8.11967 | 8.11569 | Bend | Bend | 300 | 406
02.03.03.01 Eksisterende VA, Trase2, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase2. Overvannsledning | 11.4599 | 11.4467 | Bend | Bend | 300 | 406
02.03.03.01 Eksisterende VA, Trase6, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase6. Overvannsledning | 9.41792 | 9.39319 | Bend | Bend | 300 | 406
02.03.03.01 Eksisterende VA, Trase8, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase8. Overvannsledning | 10.567 | 10.5547 | Bend | Bend | 300 | 406
02.03.03.01 Eksisterende VA, Trase4, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase4. Overvannsledning | 12.2119 | 12.2073 | Bend | Bend | 277.4 | 300 | Merknader - G105 Styrkeklasse: SN8
02.03.03.01 Eksisterende VA, Trase10, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase10. Overvannsledning | 2.78358 | 2.78344 | Bend | Bend | 300 | 406
02.03.03.01 Eksisterende VA, Trase5, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase5. Overvannsledning | 12.0804 | 11.968 | Bend | Bend | 300 | 406
02.03.03.01 Eksisterende VA, Trase_VA1, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase_VA1. Overvannsledning | 89.105 | 89.0776 | O28 | O37 | 500 | 670 | Novapoint UtilityNetwork - ToConnection: 02.03.03.01 Eksisterende VA. O29; FromConnection: 02.03.03.01 Eksisterende VA. O28
02.03.03.01 Eksisterende VA, Trase_VA1, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase_VA1. Overvannsledning | 136.857 | 136.856 | O29 | O30 | 500 | 670 | Novapoint UtilityNetwork - ToConnection: 02.03.03.01 Eksisterende VA. O30; FromConnection: 02.03.03.01 Eksisterende VA. O29
02.03.03.01 Eksisterende VA, Trase_VA1, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase_VA1. Overvannsledning | 167.188 | 167.186 | O30 | O32 | 600 | 788 | Novapoint UtilityNetwork - ToConnection: 02.03.03.01 Eksisterende VA. O32; FromConnection: 02.03.03.01 Eksisterende VA. O30
02.03.03.01 Eksisterende VA, Trase_VA4, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase_VA4. Overvannsledning | 83.7326 | 83.728 | O35 | O36 | 500 | 670 | Novapoint UtilityNetwork - ToConnection: 02.03.03.01 Eksisterende VA. O36; FromConnection: 02.03.03.01 Eksisterende VA. O35
02.03.03.01 Eksisterende VA, Trase_VA4, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase_VA4. Overvannsledning | 129.341 | 129.325 | O36 | O30 | 500 | 670 | Novapoint UtilityNetwork - ToConnection: 02.03.03.01 Eksisterende VA. O30; FromConnection: 02.03.03.01 Eksisterende VA. O36
02.03.03.01 Eksisterende VA, Trase_VA3, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase_VA3. Overvannsledning | 155.864 | 155.832 | O34 | O30 | 300 | 406 | Novapoint UtilityNetwork - ToConnection: 02.03.03.01 Eksisterende VA. O30; FromConnection: 02.03.03.01 Eksisterende VA. O34
02.03.03.01 Eksisterende VA, Deler av sandfang rives, Overvannsledning | 02.03.03.01 Eksisterende VA. Deler av sandfang rives. Overvannsledning | 22.2554 | 22.2522 | O33 | Lokk og kjegle tas inn i rivemodell | 376.6 | 400 | Novapoint UtilityNetwork - ToConnection: 02.03.03.01 Eksisterende VA. Lokk og kjegle tas inn i rivemodell; FromConnection: 02.03.03.01 Eksisterende VA. O33; Merknader - G105 Styrkeklasse: SN8 SDR 34
02.03.03.01 Eksisterende VA, Lokk endres på kum, Overvannsledning | 02.03.03.01 Eksisterende VA. Lokk endres på kum. Overvannsledning | 14.7611 | 14.7503 | Bend | O8 | 277.4 | 300 | Novapoint UtilityNetwork - ToConnection: 02.03.03.01 Eksisterende VA. O8; Merknader - G105 Styrkeklasse: SN8
02.03.03.01 Eksisterende VA, Lokk endres på kum, Overvannsledning | 02.03.03.01 Eksisterende VA. Lokk endres på kum. Overvannsledning | 17.7706 | 17.7495 | O8 | Bend | 400 | 526 | Novapoint UtilityNetwork - FromConnection: 02.03.03.01 Eksisterende VA. O8
02.03.03.01 Eksisterende VA, Trase_VA2, Overvannsledning | 02.03.03.01 Eksisterende VA. Trase_VA2. Overvannsledning | 96.5915 | 96.5656 | O33 | O29 | 400 | 526 | Novapoint UtilityNetwork - ToConnection: 02.03.03.01 Eksisterende VA. O29; FromConnection: 02.03.03.01 Eksisterende VA. O33

# IfcFlowTerminal (44)
Name | ManholeMateriale | ManholeInnerBottomZ | ManholeSumpDepth | G004 Diameter | Color | ManholeName | ManholeHeight | ManholeDiameter | ManholeMaterial | Volume (m3) = Volume_Quadri (m3) | Bruksomraade
02.03.03.01 Eksisterende VA, Lokk og kjegle tas inn i rivemodell, Bunnseksjon | Betong | 14.649 | 304 | 1000 | 0.0.0
02.03.03.01 Eksisterende VA, Lokk og kjegle tas inn i rivemodell, Bunnplate | Betong | 14.649 | 304 | 1000 | 0.0.0 | Lokk og kjegle tas inn i rivemodell | 2.22399 | 1000 | Betong | 0.100689
02.03.03.01 Eksisterende VA, Lokk og kjegle tas inn i rivemodell, Bunnring | Betong | 14.649 | 304 | 1000 | 0.0.0 | Lokk og kjegle tas inn i rivemodell | 2.22399 | 1000 | Betong | 0.460821
02.03.03.01 Eksisterende VA, Lokk og kjegle tas inn i rivemodell, Kjegle | Betong |  |  | 650 | 0.0.0 | Lokk og kjegle tas inn i rivemodell | 2.22399 | 1000 | Betong | 0.141879 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: SA
02.03.03.01 Eksisterende VA, Lokk og kjegle tas inn i rivemodell, Justeringsring | Betong |  |  | 650 | 0.0.0 | Lokk og kjegle tas inn i rivemodell | 2.22399 | 1000 | Betong | 0.0192643 | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingDiameter: 650; ManholeAdjustingUnitHeight: 100
02.03.03.01 Eksisterende VA, Lokk og kjegle tas inn i rivemodell, Lokk |  |  |  |  |  | Lokk og kjegle tas inn i rivemodell |  |  |  | 0.0149451 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK Rist; Merknader - G009 Lokktype: SJK Rist
02.03.03.01 Eksisterende VA, O37, Bunnplate | Betong | 12.8181 | 0 | 1000 | 0.0.0 | O37 | 1.24155 | 1000 | Betong | 0.100689 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O37, Bunnseksjon | Betong | 12.8181 | 0 | 1000 | 0.0.0 |  |  |  |  |  | Inspeksjonskum
02.03.03.01 Eksisterende VA, O37, Bunnring | Betong | 12.8181 | 0 | 1000 | 0.0.0 | O37 | 1.24155 | 1000 | Betong | 0.352302 | Inspeksjonskum
02.03.03.01 Eksisterende VA, SA43, Bunnseksjon | Betong | 13.6856 | 1000 | 1000 | 0.0.0
02.03.03.01 Eksisterende VA, SA43, Bunnplate | Betong | 13.6856 | 1000 | 1000 | 0.0.0 | SA43 | 2.00035 | 1000 | Betong | 0.100689
02.03.03.01 Eksisterende VA, SA43, Bunnring | Betong | 13.6856 | 1000 | 1000 | 0.0.0 | SA43 | 2.00035 | 1000 | Betong | 0.397362
02.03.03.01 Eksisterende VA, SA43, Justeringsring | Betong |  |  | 650 | 0.0.0 | SA43 | 2.00035 | 1000 | Betong | 0.0192643 | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingDiameter: 650; ManholeAdjustingUnitHeight: 100
02.03.03.01 Eksisterende VA, SA43, Kjegle | Betong |  |  | 650 | 0.0.0 | SA43 | 2.00035 | 1000 | Betong | 0.141879 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: SA
02.03.03.01 Eksisterende VA, SA43, Lokk |  |  |  |  |  | SA43 |  |  |  | 0.0647619 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK Kuppelrist; Merknader - G009 Lokktype: SJK Kuppelrist
02.03.03.01 Eksisterende VA, O32, Bunnseksjon | Betong | 10.6113 | 0 | 1000 | 0.0.0 |  |  |  |  |  | Inspeksjonskum
02.03.03.01 Eksisterende VA, O32, Bunnplate | Betong | 10.6113 | 0 | 1000 | 0.0.0 | O32 | 0.638691 | 1000 | Betong | 0.100689 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O32, Bunnring | Betong | 10.6113 | 0 | 1000 | 0.0.0 | O32 | 0.638691 | 1000 | Betong | 0.181234 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O30, Bunnseksjon | Betong | 11.3896 | 0 | 1000 | 0.0.0 |  |  |  |  |  | Inspeksjonskum
02.03.03.01 Eksisterende VA, O30, Bunnplate | Betong | 11.3896 | 0 | 1000 | 0.0.0 | O30 | 1.61044 | 1000 | Betong | 0.100689 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O30, Bunnring | Betong | 11.3896 | 0 | 1000 | 0.0.0 | O30 | 1.61044 | 1000 | Betong | 0.456975 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O28, Bunnplate | Betong | 14.6715 | 0 | 1000 | 0.0.0 | O28 | 1.47382 | 1000 | Betong | 0.100689 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O28, Bunnseksjon | Betong | 14.6715 | 0 | 1000 | 0.0.0 |  |  |  |  |  | Inspeksjonskum
02.03.03.01 Eksisterende VA, O28, Bunnring | Betong | 14.6715 | 0 | 1000 | 0.0.0 | O28 | 1.47382 | 1000 | Betong | 0.418209 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O35, Bunnseksjon | Betong | 14.2786 | 0 | 1000 | 0.0.0 |  |  |  |  |  | Inspeksjonskum
02.03.03.01 Eksisterende VA, O35, Bunnplate | Betong | 14.2786 | 0 | 1000 | 0.0.0 | O35 | 2.70688 | 1000 | Betong | 0.100689 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O35, Bunnring | Betong | 14.2786 | 0 | 1000 | 0.0.0 | O35 | 2.70688 | 1000 | Betong | 0.768102 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O36, Bunnseksjon | Betong | 13.3989 | 0 | 1000 | 0.0.0 |  |  |  |  |  | Inspeksjonskum
02.03.03.01 Eksisterende VA, O36, Bunnplate | Betong | 13.3989 | 0 | 1000 | 0.0.0 | O36 | 2.62101 | 1000 | Betong | 0.100689 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O36, Bunnring | Betong | 13.3989 | 0 | 1000 | 0.0.0 | O36 | 2.62101 | 1000 | Betong | 0.743733 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O34, Bunnseksjon | Betong | 14.3013 | 0 | 1000 | 0.0.0 |  |  |  |  |  | Inspeksjonskum
02.03.03.01 Eksisterende VA, O34, Bunnplate | Betong | 14.3013 | 0 | 1000 | 0.0.0 | O34 | 0.853 | 1000 | Betong | 0.100689 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O34, Bunnring | Betong | 14.3013 | 0 | 1000 | 0.0.0 | O34 | 0.853 | 1000 | Betong | 0.242046 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O33, Bunnring | Betong | 14.264 | 0 | 1000 | 0.0.0 | O33 | 1.33978 | 1000 | Betong | 0.380174 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O8, Bunnseksjon | Betong | 42.726 | 0 | 1000 | 0.0.0 |  |  |  |  |  | Inspeksjonskum
02.03.03.01 Eksisterende VA, O8, Bunnplate | Betong | 42.726 | 0 | 1000 | 0.0.0 | O8 | 0.798 | 1000 | Betong | 0.0828 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O8, Kjegle | Betong |  |  |  | 0.0.0 | O8 | 0.798 | 1000 | Betong | 0.0324 | Novapoint UtilityNetwork - ManholeTaperHeight: 100; Bruksomraade 1269: Inspeksjonskum
02.03.03.01 Eksisterende VA, O8, Lokk |  |  |  |  |  | O8 |  |  |  | 0.0158776 | Novapoint UtilityNetwork - ManholeCoverType: SJK Rist; Merknader - G009 Lokktype: SJK Rist
02.03.03.01 Eksisterende VA, O8, Bunnring | Betong | 42.726 | 0 | 1000 | 0.0.0 | O8 | 0.798 | 1000 | Betong | 0.226152 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O33, Bunnseksjon | Betong | 14.264 | 0 | 1000 | 0.0.0 |  |  |  |  |  | Inspeksjonskum
02.03.03.01 Eksisterende VA, O33, Bunnplate | Betong | 14.264 | 0 | 1000 | 0.0.0 | O33 | 1.33978 | 1000 | Betong | 0.100689 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O29, Bunnseksjon | Betong | 12.0266 | 0 | 1000 | 0.0.0 |  |  |  |  |  | Inspeksjonskum
02.03.03.01 Eksisterende VA, O29, Bunnplate | Betong | 12.0266 | 0 | 1000 | 0.0.0 | O29 | 1.93685 | 1000 | Betong | 0.100689 | Inspeksjonskum
02.03.03.01 Eksisterende VA, O29, Bunnring | Betong | 12.0266 | 0 | 1000 | 0.0.0 | O29 | 1.93685 | 1000 | Betong | 0.549597 | Inspeksjonskum
