Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [Default Description]
File name: \\files\Projects\RWA2024N005XX\RWA2024N00575\Leveranse\Elektro\20260604 - Leveranse inkl. BKK\m_g-elektro_60773.ifc
Time: 2026-06-04T15:21:10
Author: Stian Ingebrigtsen
Organization: Trimble Solutions Sandvika AS
Written by: Ifc Engine <1.0.1.1369>
Made in: Trimble Inc. - Novapoint - 27.0.1273.0
Authorization: Stian Ingebrigtsen

# IfcProject, Default Project
Description: Description of the Project

# IfcSite, Default Site
Description: Description of Site; RefLatitude: 5, 7, 9; RefLongitude: 60, 51, 9; RefElevation: 12.406 m

# IfcBuilding, Default Building
Description: Description of Building; ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0

# IfcBuildingStorey
In: Default Building
Description: Land Development storey; Elevation: 0 m

# IfcBuildingElementProxy: ProxyFeature (617)
Description: The IfcProxy is intended to be a kind of a container for wrapping objects which are defined by associated properties, which may or may not have a geometric representation and placement in space. A proxy may have a semantic meaning, defined by the Name attribute, and property definitions, attached through the property assignment relationship, which definition may be outside of the definitions given by the current release of IFC.
Merknader - A202 MMI: 600; A108 Godkjent av: JODY; A107 Kontrollert av: EISL; A106 Utført av: STGT; A105 Produsert for: Vestland fylke; A104 Produsert av: Rambøll; A100 Fagkode: I_Elektro; A103 Revisjonsmerknad: -; A102 Revisjonsdato: -; A101 Revisjonsbokstav: -; A005 Koordinatsystem: NTM5/NN2000; A004 Område: S1-SX; A003 Prosjektfase: Prosjektering; A002 Prosjektnummer: 060773; A001 Prosjektnavn: Fv. 570 Steine - Hovden; A201 Objektnavn: -; A200 Objektkode: -; A203 Objektstatus: Eksisterende; A213 Bemerkning: -
Name
84 x BKK_Lavspent_Jord
60 x Telenor_Jord
294 x Mast
16 x Skap
62 x Telenor_kabelTV
30 x Eviny_Digital_Jord
42 x BKK_lavspent_jord_veilys
6 x BKK_Lavspent_Luft
10 x BKK_Høyspent_Jord
6 x Telenor_Luft
4 x BKK_Høyspent_Luft
3 x Trekkekum
