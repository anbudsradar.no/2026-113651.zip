Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Alignment-basedView]
File name: J:\Fv0570\Steine-Hovden\03Prosjektering\Arbeidsmappe\Fagmodeller\Fag\vegutst\m_f-veg-sikringsgjerde_060773.ifc
Time: 2026-04-28T15:00:04
Author: Henrik Eikemo Waring
Organization: Trimble Solutions Sandvika AS
Written by: Ifc Engine <1.0.1.1374>
Made in: Trimble Inc. - Novapoint - 28.0.440.0
Authorization: Henrik Eikemo Waring

# IfcProject, Default Project
Description: Description of the Project

# IfcSite, Default Site
RefLatitude: 5, 7, 14; RefLongitude: 60, 50, 59; RefElevation: 17.1539 m

# IfcActor (2)
Name
 | Pset_Address - Purpose: OFFICE; AddressLines: Leif Tronstads plass 4; Town: Sandvika; Country: Norway


# IfcFacility, Description of default Facility
Description: Default Facility

# IfcFacilityPartCommon, Default Facility Part Common
Description: Description of Default Facility Part Common

# IfcRailing (5)
In: Default Facility Part Common
TRMB_QUADRI_Qto_BaseQuantities - ShortestHorizontalLength: 0.05 m
Name | Volume (m3) | Height (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
 | 1.01818 | 2.31253 | 16.9707 | 0.848483
 | 2.30112 | 4.63799 | 38.3543 | 1.9176
 | 15.0173 | 6.80928 | 250.293 | 12.5144
 | 7.48729 | 9.90002 | 87.0231 | 6.23941
 | 6.32596 | 5.28131 | 105.437 | 5.27164
