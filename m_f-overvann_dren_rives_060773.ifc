Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [Default Description]
File name: \\files\Projects\RWA2024N005XX\RWA2024N00575\VA\Modell\f-dren_rives.ifc
Time: 2026-02-27T08:24:59
Author: Jørgen Dybdahl
Organization: Trimble Solutions Sandvika AS
Written by: Ifc Engine <1.0.1.1369>
Made in: Trimble Inc. - Novapoint - 27.0.999.0
Authorization: Jørgen Dybdahl

# IfcProject, Default Project
Description: Description of the Project

# IfcSite, Default Site
Description: Description of Site; RefLatitude: 5, 7, 13; RefLongitude: 60, 51, 0; RefElevation: 16.2729 m

# IfcBuilding, Default Building
Description: Description of Building; ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0

# IfcBuildingStorey
In: Default Building
Description: Land Development storey; Elevation: 0 m

# IfcFlowTerminal (5)
Novapoint UtilityNetwork - UtilityNetworkType: WS_StormwaterPipeNetwork
Name | Color | ManholeName | ManholeDiameter | ManholeMaterial = ManholeMateriale | ManholeHeight | Volume (m3) = Volume_Quadri (m3)
02.03.03.01 Eksisterende VA, Lokk og kjegle tas inn i rivemodell, Kjegle | 0.0.0 | Lokk og kjegle tas inn i rivemodell | 1000 | Betong | 2.22399 | 0.141879 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: SA
02.03.03.01 Eksisterende VA, Lokk og kjegle tas inn i rivemodell, Justeringsring | 0.0.0 | Lokk og kjegle tas inn i rivemodell | 1000 | Betong | 2.22399 | 0.0192643 | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingDiameter: 650; ManholeAdjustingUnitHeight: 100
02.03.03.01 Eksisterende VA, Lokk og kjegle tas inn i rivemodell, Lokk |  | Lokk og kjegle tas inn i rivemodell |  |  |  | 0.0149451 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK Rist
02.03.03.01 Eksisterende VA, O8, Kjegle | 0.0.0 | O8 | 1000 | Betong | 0.798 | 0.0324 | Novapoint UtilityNetwork - ManholeTaperHeight: 100; Bruksomraade 1269: Inspeksjonskum
02.03.03.01 Eksisterende VA, O8, Lokk |  | O8 |  |  |  | 0.0158776 | Novapoint UtilityNetwork - ManholeCoverType: SJK Rist
