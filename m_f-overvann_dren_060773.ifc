Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [Default Description]
File name: \\files\Projects\RWA2024N005XX\RWA2024N00575\VA\Modell\f-dren.ifc
Time: 2026-05-27T12:34:49
Author: Jørgen Dybdahl
Organization: Trimble Solutions Sandvika AS
Written by: Ifc Engine <1.0.1.1369>
Made in: Trimble Inc. - Novapoint - 27.0.999.0
Authorization: Jørgen Dybdahl

# IfcProject, Default Project
Description: Description of the Project

# IfcSite, Default Site
Description: Description of Site; RefLatitude: 5, 7, 14; RefLongitude: 60, 51, 0; RefElevation: 13.6549 m

# IfcBuilding, Default Building
Description: Description of Building; ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0

# IfcBuildingStorey
In: Default Building
Description: Land Development storey; Elevation: 0 m

# IfcDistributionFlowElement (14)
Novapoint UtilityNetwork - ManholeHasLadder: 0
Common - Color: 0.0.0
Merknader - A202 MMI: 400; A108 Godkjent av: JODY; A107 Kontrollert av: JODY; A106 Utført av: SAUE; A105 Produsert for: Vestland Fylke; A104 Produsert av: RAMBØLL; A100 Fagkode: G_Dren; A005 Koordinatsystem: NTM5/NN2000; A004 Område: S1-SX; A003 Prosjektfase: Prosjektering; A002 Prosjektnummer: 060773; A001 Prosjektnavn: Fv. 570 Steine - Hovden; G003 Eier av anlegget: Vestland Fylkeskommune
Name | Name | Navn = G100 Ledningstype | ManholeMateriale | ManholeHeight | ManholeElevationAtTop | ManholeTaperDiameter | ManholeAdjustingUnitHeight | ManholeInnerBottomZ | ManholeSumpDepth | G004 Diameter | G009 Lokktype | A200 Objektkode | A201 Objektnavn | G010 Dykker | G008 Diameter lokk
f-dren, SF01 | f-dren. SF01 | SF01 | Betong | 1.7799 | 42.7284 | 650 | 100 | 40.9485 | 1000 | 1000 | SJK Kuppelrist | 46110000 | sandfangskummer | Ja | 650mm
f-dren, ST06 | f-dren. ST06 | ST06 | Polypropylen | 1.28625 | 35.4149 | 400 | 0 | 34.1286 | 0 | 400 | SJK | 46390000 | Inspeksjonskummer | Nei | 400
f-dren, ST08 | f-dren. ST08 | ST08 | Polypropylen | 1.1365 | 25.2906 | 400 | 0 | 24.1541 | 0 | 400 | SJK | 46390000 | Inspeksjonskummer | Nei | 400
f-dren, ST07 | f-dren. ST07 | ST07 | Polypropylen | 1.27768 | 30.6917 | 400 | 0 | 29.414 | 0 | 400 | SJK | 46390000 | Inspeksjonskummer | Nei | 400
f-dren, ST04 | f-dren. ST04 | ST04 | Polypropylen | 1.1365 | 37.3203 | 400 | 0 | 36.1838 | 0 | 400 | SJK | 46390000 | Inspeksjonskummer | Nei | 400
f-dren, ST01 | f-dren. ST01 | ST01 | Polypropylen | 1.1365 | 42.8428 | 400 | 0 | 41.7063 | 0 | 400 | SJK | 46390000 | Inspeksjonskummer | Nei | 400
f-dren, ST03 | f-dren. ST03 | ST03 | Polypropylen | 1.36205 | 38.4703 | 400 | 0 | 37.1082 | 0 | 400 | SJK | 46390000 | Inspeksjonskummer | Nei | 400
f-dren, ST05 | f-dren. ST05 | ST05 | Polypropylen | 1.18834 | 36.2798 | 400 | 0 | 35.0914 | 0 | 400 | SJK | 46390000 | Inspeksjonskummer | Nei | 400
f-dren, ST02 | f-dren. ST02 | ST02 | Polypropylen | 1.32076 | 40.2482 | 400 | 0 | 38.9275 | 0 | 400 | SJK | 46390000 | Inspeksjonskummer | Nei | 400
f-dren, ST10 | f-dren. ST10 | ST10 | Polypropylen | 1.28495 | 17.8462 | 0 | 0 | 16.5612 | 0 | 400 | SJK | 46390000 | Inspeksjonskummer | Nei | 400
f-dren, SF03 | f-dren. SF03 | SF03 | Betong | 1.96881 | 15.7238 | 650 | 100 | 13.755 | 1000 | 1000 | SJK Kuppelrist | 46110000 | sandfangskummer | Ja | 650mm
f-dren, O01 | f-dren. O01 | O01 | Betong | 1.69247 | 16.3881 | 650 | 0 | 14.6956 | 0 | 1000 | SJK | 46310000 | inspeksjonskummer | Nei | 650mm | Novapoint UtilityNetwork - Bruksomraade: Inspeksjonskum
f-dren, SF04 | f-dren. SF04 | SF04 | Betong | 1.6368 | 15.5624 | 650 | 200 | 13.9256 | 1000 | 1000 | SJK Kuppelrist | 46110000 | sandfangskummer | Ja | 650mm
f-dren, ST09 | f-dren. ST09 | ST09 | Polypropylen | 1.15098 | 19.1347 | 400 | 0 | 17.9837 | 0 | 315 | SJK | 46390000 | Inspeksjonskummer | Nei | 400

# IfcFlowSegment (32)
Novapoint UtilityNetwork - Volume: 0 m3
Merknader - G003 Eier av anlegget: Vestland Fylkeskommune; A108 Godkjent av: JODY; A107 Kontrollert av: JODY; A106 Utført av: SAUE; A105 Produsert for: Vestland Fylke; A104 Produsert av: RAMBØLL; A100 Fagkode: G_Dren; A005 Koordinatsystem: NTM5/NN2000; A004 Område: S1-SX; A003 Prosjektfase: Prosjektering; A002 Prosjektnummer: 060773; A001 Prosjektnavn: Fv. 570 Steine - Hovden
Name | Name | Navn = G100 Ledningstype | PipeNetworkUsage | Length (m) | Color | G106 Fall | G107 Lengde | G101 Fra kum | G102 Til kum | G103 Innvendig dimensjon | G104 Utvendig dimensjon | A202 MMI | A201 Objektnavn | A200 Objektkode | G105 Styrkeklasse
f-dren, Trase27, Overvannsledning | f-dren. Trase27. Overvannsledning | Overvannsledning | Surface Water | 4.08612 | 0.0.0 | -44.2 | 4.08213 | Bend | Bend | 400 | 526
f-dren, Forlenging stikkrenne 3, Overvannsledning | f-dren. Forlenging stikkrenne 3. Overvannsledning | Overvannsledning | Surface Water | 3.22194 | 0.0.0 | 183.6 | 3.16895 | Bend | Bend | 300 | 406 | 400 | OV BET DN300 | 45210000
f-dren, Trase1, Overvannsledning | f-dren. Trase1. Overvannsledning | Overvannsledning | Surface Water | 33.3706 | 0.0.0 | -10.0 | 33.3689 | Bend | Bend | 1000 | 1230 | 400 | OV BET 1000 | 45260000
f-dren, Avkjørsel 2, Overvannsledning | f-dren. Avkjørsel 2. Overvannsledning | Overvannsledning | Surface Water | 9.76744 | 0.0.0 | -31.7 | 9.76253 | Bend | Bend | 300 | 406 | 400 | OV BET 300 | 45210000
f-dren, Avkjørsel 1, Overvannsledning | f-dren. Avkjørsel 1. Overvannsledning | Overvannsledning | Surface Water | 8.19081 | 0.0.0 | -21.9 | 8.18885 | Bend | Bend | 300 | 406 | 400 | OV BET DN300 | 45210000
f-dren, SF1, Overvannsledning | f-dren. SF1. Overvannsledning | Overvannsledning | Surface Water | 17.1433 | 0.0.0 | 10.0 | 17.1424 | Bend | SF01 | 149 | 160 | 400 | OV PP 160 | 43210000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. SF01
f-dren, Forlenging stikkrenne 1, Overvannsledning | f-dren. Forlenging stikkrenne 1. Overvannsledning | Overvannsledning | Surface Water | 2.97667 | 0.0.0 | 245.8 | 2.89062 | Bend | Bend | 300 | 406 | 400 | OV BET DN300 | 45210000
f-dren, Forlenging stikkrenne 2, Overvannsledning | f-dren. Forlenging stikkrenne 2. Overvannsledning | Overvannsledning | Surface Water | 3.9033 | 0.0.0 | 108.3 | 3.88061 | Bend | Bend | 300 | 406 | 400 | OV BET DN300 | 45210000
f-dren, Lukket drenering, Drensledning | f-dren. Lukket drenering. Drensledning | Drensledning | Drain Water | 81.7911 | 192.192.192 | -57.7 | 81.6497 | ST06 | ST07 | 169 | 200 | 400 | DR DV 200 | 43122000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. ST07; FromConnection: f-dren. ST06
f-dren, Lukket drenering, Drensledning | f-dren. Lukket drenering. Drensledning | Drensledning | Drain Water | 75.4297 | 192.192.192 | -69.9 | 75.2444 | ST07 | ST08 | 169 | 200 | 400 | DR DV 200 | 43122000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. ST08; FromConnection: f-dren. ST07
f-dren, Lukket drenering, Overvannsledning | f-dren. Lukket drenering. Overvannsledning | Overvannsledning | Surface Water | 6.59003 | 0.0.0 | -10.0 | 6.5897 | ST08 | Bend | 186.2 | 200 | 400 | OV PP 200 | 43220000 | SN8 | Novapoint UtilityNetwork - FromConnection: f-dren. ST08
f-dren, Forlenging stikkrenne 7, Overvannsledning | f-dren. Forlenging stikkrenne 7. Overvannsledning | Overvannsledning | Surface Water | 3.30763 | 0.0.0 | 27.7 | 3.30635 | Bend | Bend | 300 | 406 | 400 | OV BET DN300 | 45210000
f-dren, Lukket drenering, Drensledning | f-dren. Lukket drenering. Drensledning | Drensledning | Drain Water | 78.0377 | 192.192.192 | -14.0 | 78.03 | ST04 | ST05 | 169 | 200 | 400 | DR DV 200 | 43122000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. ST05; FromConnection: f-dren. ST04
f-dren, Forlenging stikkrenne 4, Overvannsledning | f-dren. Forlenging stikkrenne 4. Overvannsledning | Overvannsledning | Surface Water | 3.58502 | 0.0.0 | 175.2 | 3.53121 | Bend | Bend | 300 | 406 | 400 | OV BET DN300 | 45210000
f-dren, Forlenging stikkrenne 5, Overvannsledning | f-dren. Forlenging stikkrenne 5. Overvannsledning | Overvannsledning | Surface Water | 3.92915 | 0.0.0 | 44.7 | 3.92523 | Bend | Bend | 300 | 406 | 400 | OV BET DN300 | 45210000
f-dren, Utløp drenering 2, Overvannsledning | f-dren. Utløp drenering 2. Overvannsledning | Overvannsledning | Surface Water | 14.6985 | 0.0.0 | -10.2 | 14.6977 | ST05 | Trasepunkt | 149 | 160 | 400 | OV PP 160 | 43210000 | SN8 | Novapoint UtilityNetwork - FromConnection: f-dren. ST05
f-dren, Lukket drenering, Drensledning | f-dren. Lukket drenering. Drensledning | Drensledning | Drain Water | 80.2286 | 192.192.192 | -34.7 | 80.1689 | ST01 | ST02 | 169 | 200 | 400 | DR DV 200 | 43122000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. ST02; FromConnection: f-dren. ST01
f-dren, Lukket drenering, Drensledning | f-dren. Lukket drenering. Drensledning | Drensledning | Drain Water | 69.5519 | 192.192.192 | -26.2 | 69.527 | ST02 | ST03 | 169 | 200 | 400 | DR DV 200 | 43122000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. ST03; FromConnection: f-dren. ST02
f-dren, Lukket drenering, Drensledning | f-dren. Lukket drenering. Drensledning | Drensledning | Drain Water | 82.2064 | 192.192.192 | -11.2 | 82.201 | ST03 | ST04 | 169 | 200 | 400 | DR DV 200 | 43122000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. ST05; FromConnection: f-dren. ST03
f-dren, Lukket drenering, Drensledning | f-dren. Lukket drenering. Drensledning | Drensledning | Drain Water | 80.7177 | 192.192.192 | -11.9 | 80.7106 | ST05 | ST06 | 169 | 200 | 400 | DR DV 200 | 43122000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. ST06; FromConnection: f-dren. ST05
f-dren, Utløp drenering 1, Overvannsledning | f-dren. Utløp drenering 1. Overvannsledning | Overvannsledning | Surface Water | 15.1029 | 0.0.0 | -11.1 | 15.1019 | ST03 | Trasepunkt | 149 | 160 | 400 | OV PP 160 | 43210000 | SN8 | Novapoint UtilityNetwork - FromConnection: f-dren. ST03
f-dren, Trase26, Overvannsledning | f-dren. Trase26. Overvannsledning | Overvannsledning | Surface Water | 4.56163 | 0.0.0 | -15.2 | 4.56111 | Bend | Bend | 300 | 406 | 400 | OV BET DN300 | 43210000
f-dren, Trase24, Drensledning | f-dren. Trase24. Drensledning | Drensledning | Drain Water | 65.2201 | 192.192.192 | -16.6 | 65.211 | ST10 | Trasepunkt | 123 | 150 | 400 | DR DV 150 | 43121000 | SN8 | Novapoint UtilityNetwork - FromConnection: f-dren. ST10
f-dren, Trase24, Drensledning | f-dren. Trase24. Drensledning | Drensledning | Drain Water | 79.6571 | 192.192.192 | -17.9 | 79.6442 | ST09 | ST10 | 123 | 150 | 400 | DR DV 150 | 43121000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. ST10; FromConnection: f-dren. ST09
f-dren, Trase25, Drensledning | f-dren. Trase25. Drensledning | Drensledning | Drain Water | 0.983072 | 192.192.192 | 169.6 | 0.870034 | Eks SF2 | Trasepunkt | 123 | 150 | 400 | DR DV 150 | 43121000 | SN8 | Novapoint UtilityNetwork - FromConnection: f-dren. Eks SF2
f-dren, Trase25, Drensledning | f-dren. Trase25. Drensledning | Drensledning | Drain Water | 84.2191 | 192.192.192 | -6.0 | 84.2174 | Trasepunkt | SF03 | 123 | 150 | 400 | DR DV 150 | 43121000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. SF03
f-dren, Trase24, Drensledning | f-dren. Trase24. Drensledning | Drensledning | Drain Water | 17.4792 | 192.192.192 | -11.1 | 17.4781 | Trasepunkt | Eks SF2 | 123 | 150 | 400 | DR DV 150 | 43121000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. Eks SF2
f-dren, Forlenging stikkrenne 6, Overvannsledning | f-dren. Forlenging stikkrenne 6. Overvannsledning | Overvannsledning | Surface Water | 3.46374 | 0.0.0 | 1.1 | 3.46374 | Bend | Bend | 300 | 406 | 400 | OV BET DN300 | 45210000
f-dren, Trase18, Overvannsledning | f-dren. Trase18. Overvannsledning | Overvannsledning | Surface Water | 69.4546 | 0.0.0 | 5.1 | 69.4537 | Bend | O01 | 231.8 | 250 | 400 | OV PP 250 | 43230000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. O01
f-dren, Trase18, Overvannsledning | f-dren. Trase18. Overvannsledning | Overvannsledning | Surface Water | 18.8921 | 0.0.0 | 12.1 | 18.8907 | O01 | SF04 | 149 | 160 | 400 | OV PP 160 | 43210000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. SF04; FromConnection: f-dren. O01
f-dren, Avkjørsel 4, Overvannsledning | f-dren. Avkjørsel 4. Overvannsledning | Overvannsledning | Surface Water | 6.49834 | 0.0.0 | -23.0 | 6.49662 | Bend | Bend | 300 | 406 | 400 | OV BET DN300 | 45210000
f-dren, Trase19, Overvannsledning | f-dren. Trase19. Overvannsledning | Overvannsledning | Surface Water | 9.57893 | 0.0.0 | 6.2 | 9.57875 | O01 | SF03 | 149 | 160 | 400 | OV PP 160 | 43210000 | SN8 | Novapoint UtilityNetwork - ToConnection: f-dren. SF03; FromConnection: f-dren. O01

# IfcFlowTerminal (76)
Name | ManholeMateriale | ManholeInnerBottomZ | ManholeSumpDepth | G004 Diameter | A202 MMI | A108 Godkjent av = A107 Kontrollert av | A106 Utført av | A105 Produsert for | A104 Produsert av | A100 Fagkode | A005 Koordinatsystem | A004 Område | A003 Prosjektfase | A002 Prosjektnummer | A001 Prosjektnavn | A200 Objektkode | A201 Objektnavn | Color | ManholeName | ManholeHeight | ManholeDiameter | ManholeMaterial | Volume (m3) = Volume_Quadri (m3) | G010 Dykker | G008 Diameter lokk | G003 Eier av anlegget
f-dren, SF01, Bunnseksjon | Betong | 40.9485 | 1000 | 1000 | 375 | JODY | MBUV | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0
f-dren, SF01, Bunnplate | Betong | 40.9485 | 1000 | 1000 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0 | SF01 | 1.7799 | 1000 | Betong | 0.100689 | Ja | 650mm | Vestland Fylkeskommune
f-dren, SF01, Bunnring | Betong | 40.9485 | 1000 | 1000 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0 | SF01 | 1.7799 | 1000 | Betong | 0.448311 | Ja | 650mm | Vestland Fylkeskommune
f-dren, SF01, Kjegle | Betong |  |  | 650 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0 | SF01 | 1.7799 | 1000 | Betong | 0.0283759 | Ja | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 100; ManholeTaperDiameter: 650; Bruksomraade 1269: SA
f-dren, SF01, Justeringsring | Betong |  |  | 650 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0 | SF01 | 1.7799 | 1000 | Betong | 0.0192643 | Ja | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingDiameter: 650; ManholeAdjustingUnitHeight: 100
f-dren, SF01, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer |  | SF01 |  |  |  | 0.129524 | Ja | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK Kuppelrist; Merknader - G009 Lokktype: SJK Kuppelrist
f-dren, ST02, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer |  | ST02 |  |  |  | 0.000115702 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 400; ManholeCoverType: SJK; Merknader - G009 Lokktype: SJK
f-dren, ST02, Kjegle | Polypropylen |  |  | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST02 | 1.32076 | 400 | Polypropylen | 0.0161486 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 545; ManholeTaperDiameter: 400; Bruksomraade 1269: ST
f-dren, ST06, Bunnseksjon | Polypropylen | 34.1286 | 0 | 400 | 375 | JODY | MBUV | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0
f-dren, ST06, Bunnplate | Polypropylen | 34.1286 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST06 | 1.28625 | 400 | Polypropylen | 0.00347105 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST06, Bunnring | Polypropylen | 34.1286 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST06 | 1.28625 | 400 | Polypropylen | 0.0219637 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST06, Kjegle | Polypropylen |  |  | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST06 | 1.28625 | 400 | Polypropylen | 0.0161486 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 545; ManholeTaperDiameter: 400; Bruksomraade 1269: ST
f-dren, ST06, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer |  | ST06 |  |  |  | 0.000115702 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 400; ManholeCoverType: SJK; Merknader - G009 Lokktype: SJK
f-dren, ST08, Bunnseksjon | Polypropylen | 24.1541 | 0 | 400 | 375 | JODY | MBUV | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0
f-dren, ST08, Bunnplate | Polypropylen | 24.1541 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST08 | 1.1365 | 400 | Polypropylen | 0.00347105 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST08, Bunnring | Polypropylen | 24.1541 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST08 | 1.1365 | 400 | Polypropylen | 0.0175264 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST04, Kjegle | Polypropylen |  |  | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST04 | 1.1365 | 400 | Polypropylen | 0.0161486 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 545; ManholeTaperDiameter: 400; Bruksomraade 1269: ST
f-dren, ST03, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer |  | ST03 |  |  |  | 0.000115702 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 400; ManholeCoverType: SJK; Merknader - G009 Lokktype: SJK
f-dren, ST04, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer |  | ST04 |  |  |  | 0.000115702 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 400; ManholeCoverType: SJK; Merknader - G009 Lokktype: SJK
f-dren, ST08, Kjegle | Polypropylen |  |  | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST08 | 1.1365 | 400 | Polypropylen | 0.0161486 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 545; ManholeTaperDiameter: 400; Bruksomraade 1269: ST
f-dren, ST08, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer |  | ST08 |  |  |  | 0.000115702 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 400; ManholeCoverType: SJK; Merknader - G009 Lokktype: SJK
f-dren, ST07, Bunnseksjon | Polypropylen | 29.414 | 0 | 400 | 375 | JODY | MBUV | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0
f-dren, ST07, Bunnplate | Polypropylen | 29.414 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST07 | 1.27768 | 400 | Polypropylen | 0.00347105 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST07, Bunnring | Polypropylen | 29.414 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST07 | 1.27768 | 400 | Polypropylen | 0.0217097 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST07, Kjegle | Polypropylen |  |  | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST07 | 1.27768 | 400 | Polypropylen | 0.0161486 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 545; ManholeTaperDiameter: 400; Bruksomraade 1269: ST
f-dren, ST07, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer |  | ST07 |  |  |  | 0.000115702 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 400; ManholeCoverType: SJK; Merknader - G009 Lokktype: SJK
f-dren, ST04, Bunnseksjon | Polypropylen | 36.1838 | 0 | 400 | 375 | JODY | MBUV | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0
f-dren, ST04, Bunnplate | Polypropylen | 36.1838 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST04 | 1.1365 | 400 | Polypropylen | 0.00347105 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST04, Bunnring | Polypropylen | 36.1838 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST04 | 1.1365 | 400 | Polypropylen | 0.0175264 | Nei | 400 | Vestland Fylkeskommune
f-dren, Eks SF1, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46192000 | Justeringsring og tett lokk til eksisterende sandfang |  | Eks SF1 |  |  |  | 0.000498168 |  |  | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK; Merknader - G009 Lokktype: SJK
f-dren, Eks SF1, Justeringsring | Betong |  |  | 650 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46192000 | Justeringsring og tett lokk til eksisterende sandfang | 0.0.0 | Eks SF1 | 2.7553 | 1000 | Betong | 0.0192643 |  |  | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingDiameter: 650; ManholeAdjustingUnitHeight: 100
f-dren, ST01, Bunnseksjon | Polypropylen | 41.7063 | 0 | 400 | 375 | JODY | MBUV | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0
f-dren, ST01, Bunnplate | Polypropylen | 41.7063 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST01 | 1.1365 | 400 | Polypropylen | 0.00347105 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST01, Bunnring | Polypropylen | 41.7063 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST01 | 1.1365 | 400 | Polypropylen | 0.0175264 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST01, Kjegle | Polypropylen |  |  | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST01 | 1.1365 | 400 | Polypropylen | 0.0161486 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 545; ManholeTaperDiameter: 400; Bruksomraade 1269: ST
f-dren, ST01, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer |  | ST01 |  |  |  | 0.000115702 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 400; ManholeCoverType: SJK; Merknader - G009 Lokktype: SJK
f-dren, ST02, Bunnring | Polypropylen | 38.9275 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST02 | 1.32076 | 400 | Polypropylen | 0.0229862 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST03, Bunnseksjon | Polypropylen | 37.1082 | 0 | 400 | 375 | JODY | MBUV | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0
f-dren, ST03, Bunnplate | Polypropylen | 37.1082 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST03 | 1.36205 | 400 | Polypropylen | 0.00347105 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST03, Bunnring | Polypropylen | 37.1082 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST03 | 1.36205 | 400 | Polypropylen | 0.0242096 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST03, Kjegle | Polypropylen |  |  | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST03 | 1.36205 | 400 | Polypropylen | 0.0161486 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 545; ManholeTaperDiameter: 400; Bruksomraade 1269: ST
f-dren, ST05, Bunnseksjon | Polypropylen | 35.0914 | 0 | 400 | 375 | JODY | MBUV | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0
f-dren, ST05, Bunnplate | Polypropylen | 35.0914 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST05 | 1.18834 | 400 | Polypropylen | 0.00347105 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST05, Bunnring | Polypropylen | 35.0914 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST05 | 1.18834 | 400 | Polypropylen | 0.0190624 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST05, Kjegle | Polypropylen |  |  | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST05 | 1.18834 | 400 | Polypropylen | 0.0161486 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 545; ManholeTaperDiameter: 400; Bruksomraade 1269: ST
f-dren, ST05, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer |  | ST05 |  |  |  | 0.000115702 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 400; ManholeCoverType: SJK; Merknader - G009 Lokktype: SJK
f-dren, ST02, Bunnplate | Polypropylen | 38.9275 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST02 | 1.32076 | 400 | Polypropylen | 0.00347105 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST02, Bunnseksjon | Polypropylen | 38.9275 | 0 | 400 | 375 | JODY | MBUV | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0
f-dren, ST10, Bunnseksjon | Polypropylen | 16.5612 | 0 | 400 |  |  |  |  |  |  |  |  |  |  |  |  |  | 0.0.0
f-dren, ST10, Bunnplate | Polypropylen | 16.5612 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST10 | 1.28495 | 400 | Polypropylen | 0.00347105 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST10, Bunnring | Polypropylen | 16.5612 | 0 | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST10 | 1.28495 | 400 | Polypropylen | 0.0380738 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST10, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer |  | ST10 |  |  |  | 0.000115702 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 0; ManholeCoverType: SJK; Merknader - G009 Lokktype: SJK
f-dren, SF04, Bunnplate | Betong | 13.9256 | 1000 | 1000 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0 | SF04 | 1.6368 | 1000 | Betong | 0.100689 | Ja | 650mm | Vestland Fylkeskommune
f-dren, SF04, Bunnring | Betong | 13.9256 | 1000 | 1000 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0 | SF04 | 1.6368 | 1000 | Betong | 0.379329 | Ja | 650mm | Vestland Fylkeskommune
f-dren, SF04, Kjegle | Betong |  |  | 650 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0 | SF04 | 1.6368 | 1000 | Betong | 0.0283759 | Ja | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 100; ManholeTaperDiameter: 650; Bruksomraade 1269: SA
f-dren, SF04, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer |  | SF04 |  |  |  | 0.129524 | Ja | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK Kuppelrist; Merknader - G009 Lokktype: SJK Kuppelrist
f-dren, SF04, Justeringsring | Betong |  |  | 650 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0 | SF04 | 1.6368 | 1000 | Betong | 0.0385287 | Ja | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingHeight: 200; ManholeAdjustingDiameter: 650; ManholeAdjustingUnitHeight: 200
f-dren, O01, Bunnplate | Betong | 14.6956 | 0 | 1000 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46310000 | inspeksjonskummer | 0.0.0 | O01 | 1.69247 | 1000 | Betong | 0.100689 | Nei | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - Bruksomraade: Inspeksjonskum
f-dren, O01, Bunnring | Betong | 14.6956 | 0 | 1000 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46310000 | inspeksjonskummer | 0.0.0 | O01 | 1.69247 | 1000 | Betong | 0.338375 | Nei | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - Bruksomraade: Inspeksjonskum
f-dren, O01, Kjegle | Betong |  |  | 650 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46310000 | inspeksjonskummer | 0.0.0 | O01 | 1.69247 | 1000 | Betong | 0.141879 | Nei | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: Inspeksjonskum
f-dren, O01, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46310000 | inspeksjonskummer |  | O01 |  |  |  | 0.000498168 | Nei | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK; Merknader - G009 Lokktype: SJK
f-dren, Eks SF2, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46191000 | Kjegle og kuppelrist til eksisterende sandfang |  | Eks SF2 |  |  |  | 0.129524 |  | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK Kuppelrist; Merknader - G009 Lokktype: SJK Kuppelrist
f-dren, ST09, Bunnseksjon | Polypropylen | 17.9837 | 0 | 315 |  |  |  |  |  |  |  |  |  |  |  |  |  | 0.0.0
f-dren, ST09, Bunnplate | Polypropylen | 17.9837 | 0 | 315 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST09 | 1.15098 | 315 | Polypropylen | 0.0021526 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST09, Bunnring | Polypropylen | 17.9837 | 0 | 315 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST09 | 1.15098 | 315 | Polypropylen | 0.0105822 | Nei | 400 | Vestland Fylkeskommune
f-dren, ST09, Kjegle | Polypropylen |  |  | 400 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer | 0.0.0 | ST09 | 1.15098 | 315 | Polypropylen | 0.00951734 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 545; ManholeTaperDiameter: 400; Bruksomraade 1269: ST
f-dren, ST09, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46390000 | Inspeksjonskummer |  | ST09 |  |  |  | 0.00347105 | Nei | 400 | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 400; ManholeCoverType: SJK; Merknader - G009 Lokktype: SJK
f-dren, Eks SF2, Kjegle | Betong |  |  | 650 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46191000 | Kjegle og kuppelrist til eksisterende sandfang | 0.0.0 | Eks SF2 | 2.44221 | 1000 | Betong | 0.141879 |  | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: SA
f-dren, O01, Bunnseksjon | Betong | 14.6956 | 0 | 1000 | 375 | JODY | MBUV | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46310000 | inspeksjonskummer | 0.0.0 | Novapoint UtilityNetwork - Bruksomraade: Inspeksjonskum
f-dren, SF04, Bunnseksjon | Betong | 13.9256 | 1000 | 1000 | 375 | JODY | MBUV | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0
f-dren, SF03, Bunnseksjon | Betong | 13.755 | 1000 | 1000 | 375 | JODY | MBUV | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0
f-dren, SF03, Bunnplate | Betong | 13.755 | 1000 | 1000 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0 | SF03 | 1.96881 | 1000 | Betong | 0.100689 | Ja | 650mm | Vestland Fylkeskommune
f-dren, SF03, Bunnring | Betong | 13.755 | 1000 | 1000 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0 | SF03 | 1.96881 | 1000 | Betong | 0.388411 | Ja | 650mm | Vestland Fylkeskommune
f-dren, SF03, Kjegle | Betong |  |  | 650 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0 | SF03 | 1.96881 | 1000 | Betong | 0.141879 | Ja | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: SA
f-dren, SF03, Justeringsring | Betong |  |  | 650 | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer | 0.0.0 | SF03 | 1.96881 | 1000 | Betong | 0.0192643 | Ja | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingDiameter: 650; ManholeAdjustingUnitHeight: 100
f-dren, SF03, Lokk |  |  |  |  | 400 | JODY | SAUE | Vestland Fylke | RAMBØLL | G_Dren | NTM5/NN2000 | S1-SX | Prosjektering | 060773 | Fv. 570 Steine - Hovden | 46110000 | sandfangskummer |  | SF03 |  |  |  | 0.129524 | Ja | 650mm | Vestland Fylkeskommune | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK Kuppelrist; Merknader - G009 Lokktype: SJK Kuppelrist
